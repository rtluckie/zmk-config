/*
*
* Copyright (c) 2025 Ryan Luckie
* SPDX-License-Identifier: MIT
*
*/

/*                KEY POSITIONS

╭────────────────────────┬────────────────────────╮
│  0   1   2   3   4   5 │  6   7   8   9  10  11 │
│ 12  13  14  15  16  17 │ 18  19  20  21  22  23 │
│ 24  25  26  27  28  29 │ 30  31  32  33  34  35 │
╰───────────╮ 36  37  38 │ 39  40  41 ╭───────────╯
            ╰────────────┴────────────╯
╭─────────────────────────┬─────────────────────────╮
│ LT5 LT4 LT3 LT2 LT1 LT0 │ RT0 RT1 RT2 RT3 RT4 RT5 │
│ LM5 LM4 LM3 LM2 LM1 LM0 │ RM0 RM1 RM2 RM3 RM4 RM5 │
│ LB5 LB4 LB3 LB2 LB1 LB0 │ RB0 RB1 RB2 RB3 RB4 RB5 │
╰───────────╮ LH2 LH1 LH0 │ RH0 RH1 RH2 ╭───────────╯
            ╰─────────────┴─────────────╯
╭─────────────────────────┬─────────────────────────╮
│ LTX LMP LTR LTM LTI LTY │ RTY RMI RTM RMR RTP RTX │
│ LHX LHP LHR LHM LHI LHY │ RHY RHI RHM RHR RHP RHX │
│ LBX LMP LBR LBM LBI LBY │ RBY RMI RBM RBR RBP RBX │
╰───────────╮ L2  L1  L0  │ R0  R1  R2  ╭───────────╯
            ╰─────────────┴─────────────╯                  */



&leader {
	timeout-ms = <500>;
};

/ {

    #define LEADER_MACRO(NAME, BINDINGS) \
        NAME: NAME { \
			compatible = "zmk,behavior-macro"; \
            #binding-cells = <0>; \
            wait-ms = <10>; \
            tap-ms = <10>; \
            bindings = <&macro_tap BINDINGS>; \
        };

	#define LEADER_SEQ(NAME, KEYS, BINDINGS, LAYERS) \
		NAME { \
			key-positions = <KEYS>; \
			bindings = <BINDINGS>; \
			layers = <LAYERS>; \
		};

	macros {
        LEADER_MACRO(mc_section, &kp LA(N6))
	};

	leader_sequences {
		compatible = "zmk,leader-sequences";

		LEADER_SEQ(ld_sect, RB3 LH2 , &mc_section, ALL_LAYERS)
	};
};
